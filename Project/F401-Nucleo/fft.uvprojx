# Keil uVision project fft.uvprojx, settings and files
target NUCLEO-F401RE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: NUCLEO-F401RE
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xE,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/STM32F4xx_HAL_Driver/Inc;.\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group test
    Src/: stm32f4xx_it.c
    ./fft/: arm_fft_bin_data.c arm_fft_bin_example_f32.c
    ../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/STM32F4xx_LL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_pwr.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_exti.c stm32f4xx_ll_usart.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dma.c stm32f4xx_ll_tim.c stm32f4xx_ll_lptim.c stm32f4xx_ll_spi.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers/CMSIS
    Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
